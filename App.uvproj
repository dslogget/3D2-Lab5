# Keil uVision project App.uvproj, settings and files
target Sample (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: App +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Sources
    ./: App.s Clock-init.s Interrupt Handler.s RGB_LEB.s ThreadStarter.s Calc.s RKP.s
  group Library
    ./: Display.s EA-LPC2138-EDU-ASM.lib REG_DEFS.s
